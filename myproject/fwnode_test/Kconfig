## myproject/fwnode_test/Kconfig
```kconfig
# SPDX_Licnese-Identifier: GPL-2.0

config FWNODE_TEST
    tristate "FWNODE_TEST"
    
```
